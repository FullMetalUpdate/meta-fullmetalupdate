SUMMARY = "pydbus version 0.5.1"
LICENSE = "LGPLv2.1"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/LGPL-2.1;md5=1a6d268fd218675ffea8be556788b780"

inherit pypi setuptools3

SRC_URI[md5sum] = "e054c81fd9eaa550c3b566fc4049b477"
SRC_URI[sha256sum] = "583f47e63d0edd0ec6eed8cdb3fa2eaf930ec68343f6f802bbf38a438615314c"
