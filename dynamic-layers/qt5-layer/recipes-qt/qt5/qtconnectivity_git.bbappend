PACKAGECONFIG_remove = "bluez"