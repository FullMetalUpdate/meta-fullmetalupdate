PACKAGECONFIG_append = " alsa gstreamer"