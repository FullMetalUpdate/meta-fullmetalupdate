PACKAGECONFIG = "libpng eglfs gl gles2 accessibility freetype fontconfig jpeg evdev kms gbm"