
CONTAINERS_SUFFIX = "-${MACHINE}"
IMAGE_FSTYPES = "ext4"

inherit wiupdate_package_preinstalled_ostree
