
do_install_append () {
    rm -f ${D}${sbindir}/telinit
}
