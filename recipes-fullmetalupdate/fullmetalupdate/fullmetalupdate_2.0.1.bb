require fullmetalupdate.inc

RDEPENDS_${PN}_append = " \
    u-boot-fw-utils \
    socat \
"
